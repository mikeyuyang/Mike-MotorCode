# Keil uVision project MovCtrl_App.uvprojx, settings and files
target STM32F409VU (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MovCtrl_App +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx
  c include: ..\UTL;..\USER;..\CMSIS\USED;..\STD_LIB\inc;..\STD_LIB;..\FREERTOS;..\FREERTOS\include;..\BSP;..\DBM;..\COM;..\MOT;..\MOV;..\DIO;..\ECD;..\MATH;..\DIO;..\LWIP\src\include;..\LWIP\src;..\LWIP\port\STM32F1x7\FreeRTOS;..\LWIP\src\include\lwip;..\SYS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYS
    ../SYS/: SYS_Application.c
  group USER
    ../USER/: main.c
  group COM
    ../COM/: COM_SerialApplicaiton.c COM_ModbusRTU.c COM_CanApplicaiton.c COM_CanElmoDrv.c COM_Ethernet.c COM_ModbusTcp.c COM_HMI.c COM_HDProtocol1.c COM_GPS.C COM_JZSenor.c COM_HDProtocol2.c
  group DBM
    ../DBM/: DBM_Data.c
  group MOT
    ../MOT/: MOT_Pwm.c
  group ECD
    ../ECD/: ECD_SSI.c ECD_App.c
  group MATH
    ../MATH/: MTH_PID.c
  group MOV
    ../MOV/: MOV_Control.c
  group DIO
    ../DIO/: DIO_Control.c
  group UTL
    ../UTL/: UTL_Led.c UTL_1msTimer.c UTL_CRC.c UTL_USART.c UTL_EEPROM.c UTL_I2C.c UTL_Can.c UTL_Ethernet.c
  group CMSIS
    ../CMSIS/USED/: startup_stm32f429_439xx.s system_stm32f4xx.c
  group FREERTOS
    ../FREERTOS/: list.c queue.c tasks.c port.c heap_2.c timers.c event_groups.c
  group STD_LIB
    ../STD_LIB/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_fmc.c misc.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_can.c stm32f4x7_eth.c stm32f4xx_syscfg.c
    ../STD_LIB/: stm32f4xx_it.c
  group LWIP/API
    ../LWIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/CORE
    ../LWIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LWIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LWIP/NETIF
    ../LWIP/src/netif/: ethernet.c ethernetif.c
  group LWIP/PORT
    ../LWIP/port/STM32F1x7/FreeRTOS/: ethernetif.c sys_arch.c
